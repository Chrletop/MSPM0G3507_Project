# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "H:\Software\ti\M0_SDK\mspm0_sdk_2_10_00_04\tools\keil\syscfg.bat 'H:\Software\ti\M0_SDK\mspm0_sdk_2_10_00_04\MSPM0G3507_Project\keil\' empty.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\BSP;..\..\MSPM0G3507_Project;..\BSP\LCD
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ..\..\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: app_main.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c
    ./: startup_mspm0g350x_uvision.s
  group BSP
    ../BSP/LCD/: lcd.c lcd_init.c zk.c
    ../BSP/: bsp_sg90.c servo_controller.c servo_controller.h voice_i2c.c voice_i2c.h speaker_test.c speaker_test.h
